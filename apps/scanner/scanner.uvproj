# Keil uVision project scanner.uvproj, settings and files
target STM32F4 flash (ARM-ADS)
  device: STM32F407VG STMicroelectronics
  cpu: IRAM(0x20000000-0x2001FFFF) IRAM2(0x10000000-0x1000FFFF) IROM(0x8000000-0x80FFFFF) CLOCK(25000000) CPUTYPE("Cortex-M4") FPU2
  output: scanner
  c flags: Optim=1 OneElfS=1
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group user
    ./user/: Blinky.c LED.c
  group startup
    ./startup/: startup_stm32f4xx.s system_stm32f4xx.c
