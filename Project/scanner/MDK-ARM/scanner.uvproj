# Keil uVision project scanner.uvproj, settings and files
target STM32F4 flash (ARM-ADS)
  device: STM32F407VG STMicroelectronics
  cpu: IRAM(0x20000000-0x2001FFFF) IRAM2(0x10000000-0x1000FFFF) IROM(0x8000000-0x80FFFFF) CLOCK(25000000) CPUTYPE("Cortex-M4") FPU2
  output: scanner
  c flags: Optim=1 OneElfS=1
  c define: USE_STDPERIPH_DRIVER STM32F4XX
  c include: ..\..\..\Utilities\Startup;..\..\..\Utilities\STM32F4-Discovery;..\..\..\Libraries\CMSIS\Include;..\..\..\Libraries\CMSIS\ST\STM32F4xx\Include;..\..\..\Libraries\STM32F4xx_StdPeriph_Driver\inc;..\..\..\Modules\inc;..\..\scanner
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group Startup
    ../../../Utilities/Startup/: startup_stm32f4xx.s system_stm32f4xx.c
  group User
    ../../../Utilities/Startup/: stm32f4xx_it.c
    ../: main.c common.c
  group STM32F4-Discovery
    ../../../Utilities/STM32F4-Discovery/: stm32f4_discovery.c
  group STM32F4xx_StdPeriph_Driver
    ../../../Libraries/STM32F4xx_StdPeriph_Driver/src/: stm32f4xx_rcc.c misc.c stm32f4xx_gpio.c stm32f4xx_syscfg.c stm32f4xx_exti.c stm32f4xx_tim.c stm32f4xx_adc.c stm32f4xx_dma.c
  group Modules
    ../../../Modules/src/: enc_1.c enc_2.c sensor.c sensor_header.c paper_feeder.c buttons.c
